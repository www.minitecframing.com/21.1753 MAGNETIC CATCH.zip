# Autodesk Inventor assembly: 21.1753 MAGNETIC CATCH
## iProperties
Created: 2007-03
Part Number: 21.1753 MAGNETIC CATCH
Document SubType Name: Assembly
Designer: Andy Moles
Author: Andy Moles
